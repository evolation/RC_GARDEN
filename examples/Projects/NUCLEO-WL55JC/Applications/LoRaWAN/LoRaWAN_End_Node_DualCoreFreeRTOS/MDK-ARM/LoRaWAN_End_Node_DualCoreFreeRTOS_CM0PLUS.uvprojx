# Keil uVision project LoRaWAN_End_Node_DualCoreFreeRTOS_CM0PLUS.uvprojx, settings and files
target LoRaWAN_End_Node_DualCoreFreeRTOS_CM0PLUS (6160000::V6.16::ARMCLANG)
  device: STM32WL55JCIx:CM0P STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20004000-0x20007FFF) IRAM2(0x2000C000-0x2000FFFF) IROM(0x8020000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0+") TZ
  output: LoRaWAN_End_Node_DualCoreFreeRTOS_CM0PLUS +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM0PLUS,USE_HAL_DRIVER,STM32WL55xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,KMS_ENABLED
  c misc: -fshort-enums
  c include: ../CM0PLUS/Core/Inc;../CM0PLUS/KMS/App;../CM0PLUS/LoRaWAN/App;../CM0PLUS/LoRaWAN/Target;../CM0PLUS/MbMux;../Common/Board;../Common/System;../Common/MbMux;../../../../../../Drivers/BSP/STM32WLxx_Nucleo;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/ST;../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/library;../../../../../../Middlewares/Third_Party/mbed-crypto/include/mbedtls;../../../../../../Middlewares/Third_Party/mbed-crypto/include/psa;../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto;../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region;../../../../../../Middlewares/Third_Party/LoRaWAN/Mac;../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler;../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Include
  asm include: ..\CM0PLUS\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20004000 size 0x4000
  memory RVCT10: RAM 0x2000c000 size 0x4000
  scatter file: stm32wl55xx_flash_cm0plus.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm0plus.s
  group Application/User/CM0PLUS/LoRaWAN/App
    ../CM0PLUS/LoRaWAN/App/: app_lorawan.c lora_app.c
  group Application/User/CM0PLUS/LoRaWAN/Target
    ../CM0PLUS/LoRaWAN/Target/: radio_board_if.c
  group Application/User/CM0PLUS/KMS/App
    ../CM0PLUS/KMS/App/: app_kms.c
  group Application/User/CM0PLUS/Core
    ../CM0PLUS/Core/Src/: main.c gpio.c ipcc.c kms_low_level.c nvms_low_level.c ca_low_level.c ipcc_if.c stm32_lpm_if.c sys_app.c timer_if.c rtc.c subghz.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/CM0PLUS/MbMux
    ../CM0PLUS/MbMux/: features_info.c lora_info.c LmHandler_mbwrapper.c mbmux.c mbmuxif_lora.c mbmuxif_radio.c mbmuxif_sys.c mbmuxif_trace.c radio_mbwrapper.c
  group Application/User/Common/System
    ../Common/System/: sys_debug.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_ipcc.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_cryp.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_pka.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32wlxx.c
  group Middlewares/KMS
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core/: kms_der_x962.c kms_ecc.c kms_entry.c kms_init.c kms_mem.c kms_objects.c kms_platf_objects.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Modules/: kms_counter.c kms_digest.c kms_dyn_obj.c kms_enc_dec.c kms_key_mgt.c kms_nvm_storage.c kms_sign_verify.c kms_vm_storage.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/niKMS/: kms_interface.c tkms.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/: ca_aes.c ca_core.c ca_ecc.c ca_hash.c ca_if_utils.c ca_rng.c ca_rsa.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/HAL/: ca_aes_hal.c ca_ecc_hal.c ca_rsa_hal.c mac_stm32hal.c rsa_stm32hal.c
    ../../../../../../Middlewares/ST/STM32_Key_Management_Services/Interface/CryptoApi/MBED/: ca_aes_mbed.c ca_ecc_mbed.c ca_hash_mbed.c ca_rng_mbed.c ca_rsa_mbed.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: sha1.c sha256.c platform_util.c
  group Middlewares/LoRaWAN
    ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/Packages/: LmhpCompliance.c LmhpPackagesRegistration.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: cmac.c lorawan_aes.c soft-se.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/Region/: Region.c RegionAS923.c RegionAU915.c RegionBaseUS.c RegionCN470.c RegionCN470A20.c RegionCN470A26.c RegionCN470B20.c RegionCN470B26.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/LmHandler/: LmHandler.c NvmDataMgmt.c
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c radio_fw.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
